## boards/shields/mock_corne/Kconfig.defconfig
```kconfig
if SHIELD_MOCK_CORNE

config ZMK_KEYBOARD_NAME
	default "Mock Corne (kept"

endif # SHIELD_MOCK_CORNE
```
